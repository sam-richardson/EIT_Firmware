# IAR project ImpedanceMeasurement_4Wire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_SYSTEM_CLOCK_TRANSITION; ADI_DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\src; ..\inc; ..\inc\config; ..\tools
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openeitNeighbour_dist5.hex
  ILINK.IlinkOutputFile: openeit.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM350BBCZ.icf
  ILINK.IlinkAdditionalLibs: C:\Users\sric581\Documents\EIT_Firmware\iar\Debug\iar_cortexM3l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ImpedanceMeasurement_2Wire.srec
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: ImpedanceMeasurement_2Wire.out
  group (top)
    ../: Readme.txt
  group Driver Sources
    ../src/: afe.c afe_lib.c dma.c gpio.c uart.c wdt.c
  group System Sources
    ../src/: startup.c system.c
  group Test Sources
    ../: lookup.h modes.h OpenEIT_neighbour.c PinMux.c sequences.h test_common.c
    ../src/: rtc.c
    ../inc/: rtc.h
